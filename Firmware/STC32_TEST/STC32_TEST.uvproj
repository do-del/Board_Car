# Keil uVision project STC32_TEST.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: STC32_TEST +hex
  group Source Group 1
    ./Src/: main.c pwm.c motor.c math.c uart.c sys.c rf24.c spi.c timer.c
