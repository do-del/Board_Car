# Repository do-del/Board_Car

File README.md:

# Board_Car
Mini平衡小板车
项目目标：做一个非常简易小巧还能遥控的平衡小车
## 功能
- 自平衡
- 可遥控前进后退转弯

## 硬件构成
电路包括双路直流电机驱动、主控MCU、陀螺仪、电池充放电、调试电路组成，力求精简低成本
- 主控使用STM32F103CBT6，预留SWD调试接口,UART接口
- 陀螺仪使用MPU6050，I2C通讯
- 无线使用RF24无线模块，SPI通讯
- 电机驱动使用L9110SH桥驱动芯片，PWM控制
- 电池充放电使用IP5306，输出5V

## KiCad design Hardware/Board_Car_V0_3/Board_Car_V0_3.kicad_pcb

Board: 2 copper layers, 40.0 x 21.0 mm, 39 parts (15 on the bottom side), 33 nets.

Parts:
BT2: Battery_Cell; PAD_2P_P2.54mm
C1: 100uF; C_1210_3225Metric
C2, C3, C4, C7, C8, C19: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C6, C9, C10, C12, C14: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C13, C17: 22uF; C_1206_3216Metric
D1: BAT54C; SOT-23
D2: LED; LED_D5.0mm
D3: 25%; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2: Conn_01x02_Pin; PAD_2P_P2.54mm
L1: 1uH; IND0420
M1, M2: Motor_DC; PAD_2P_P2.54mm
R1: 2.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 5K1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 2R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 0.5R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 1K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW3: SW_SPDT; SWITCH_TOGGLE_2.5mm_3P
U1: SPX3819M5-L-3-3; SOT-23-5
U2, U4: L9110S; SOP-8_5.28x5.23mm_P1.27mm
U3: IP5306; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.3x2.3mm
U5: STC32G12K128; LQFP-48_7x7mm_P0.5mm
U7: RF24_SMD
USB1: TYPE-C; TYPE-C_6P_Vertical

Connections:
+3.3V: C13.1, C14.1, C19.1, R1.2, U1.5 (OUT), U5.15 (VCC), U5.16 (ADC_VRef), U7.1 (VCC)
+5V: C1.1, D1.2, U3.8 (VOUT)
+5VD: C3.1, C4.1, C5.1, C8.1, C9.1, J1.1, SW3.1 (A), U1.1 (IN), U1.3 (EN), U2.2 (VDD), U2.3 (VIO), U4.2 (VDD), U4.3 (VIO)
+BATT: BT2.2 (+), C11.1, L1.2, R12.1, R13.2
/LED: D2.1 (K), U5.1 (P5.3)
/PWM1N: U2.7 (BAK), U5.6 (P1.1)
/PWM1P: U2.6 (FOR), U5.5 (P1.0)
/PWM4N: U4.7 (BAK), U5.11 (P1.7)
/PWM4P: U4.6 (FOR), U5.10 (P1.6)
/RF24_CE: U5.40 (P2.7), U7.2 (CE)
/RF24_CSN: U5.39 (P2.6), U7.3 (CSN)
/RF24_IRQ: U5.35 (P2.2), U7.7 (IRQ)
/RF24_MISO: U5.37 (P2.4), U7.6 (MISO)
/RF24_MOSI: U5.36 (P2.3), U7.5 (MOSI)
/RF24_SCK: U5.38 (P2.5), U7.4 (SCK)
/RX: J2.2, U5.19 (P3.0)
/TX: J2.1, U5.20 (P3.1)
GND: BT2.1 (-), C1.2, C2.1, C3.2, C4.2, C5.2, C7.1, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C17.2, C19.2, D3.1 (K), J1.2, R2.2, R3.2, U1.2 (GND), U2.5 (GND), U2.8 (GND), U3.9 (PAD), U4.5 (GND), U4.8 (GND), U5.17 (GND), U7.8 (GND), USB1.A12 (GND), USB1.B12 (GND), USB1.MP (SHELL)
unnamed: C2.2, R11.1
unnamed: D2.2 (A), R1.1
unnamed: D3.2 (A), U3.2 (LED1)
unnamed: C6.1, M1.1 (+), U2.1 (X4)
unnamed: C6.2, M1.2 (-), U2.4 (X3)
unnamed: C10.1, M2.1 (+), U4.1 (X4)
unnamed: C10.2, M2.2 (-), U4.4 (X3)
unnamed: D1.3, SW3.2 (B)
unnamed: C17.1, R12.2, U3.6 (BAT)
unnamed: R13.1, U3.3 (LED2), U3.4 (LED3)
unnamed: L1.1, U3.7 (SW)
unnamed: C12.1, U5.13 (UCap)
unnamed: R2.1, USB1.A5 (CC1)
unnamed: R3.1, USB1.B5 (CC2)
VBUS: C7.2, D1.1, R11.2, U3.1 (VIN), USB1.A9 (VBUS), USB1.B9 (VBUS)

## KiCad design Hardware/Board_Car_V0_2/Board_Car_V0_2.kicad_pcb

Parts:
BT1: Battery_Cell; PH2.0_2P_LT
BZ1: Buzzer; DET402
C1, C7, C9, C13, C14, C15, C16, C17, C18: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C5, C10, C11: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 2.2nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12: 22uF; C_1206_3216Metric
D1, D2, D3: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: D; D_SOD-123
D5: BAT54C; SOT-23
J1, J2: Servo; PinHeader_1x03_P2.54mm_Vertical
M1, M2: Motor_DC; PH2.0_2P_LT
Q1: S8050; SOT-23
R1, R4, R5: 1.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 5K1; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 2.2K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 100R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R11: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10: 33R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 300R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: KEY; SW_2x4x3.5_SIDE
SW2: SW_SPDT; SW_SPDT_CK-JS102011SAQN
U1: XC6206PxxxMR; SOT-23
U2: TC4056A; ESOP8_P1.27_3.9x5_EP2.5x3.4
U3: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U4: RF24_SMD
U5: STC32G12K128; LQFP-48_7x7mm_P0.5mm
U6, U7: L9110S; SOP-8_5.28x5.23mm_P1.27mm
USB1: Type_C_16PIN; TYPE-C-16PIN_SMD

Connections:
+3.3V: BZ1.1 (-), C6.2, C7.1, C12.1, C15.1, D4.1 (K), R6.2, R11.2, U1.2 (VO), U3.8 (VLOGIC), U3.13 (VDD), U4.1 (VCC), U5.15 (VCC), U5.16 (ADC_VRef), U6.3 (VIO), U7.3 (VIO)
+BATT: BT1.2 (+), C5.1, C10.1, C11.1, C13.1, C14.1, D5.2, J1.2, J2.2, U2.5 (BAT), U6.2 (VDD), U7.2 (VDD)
/BUZZ: R7.1, U5.46 (P0.3)
/DN: R9.1, USB1.A7 (DN1), USB1.B7 (DN2)
/DP: R10.1, USB1.A6 (DP1), USB1.B6 (DP2)
/LED: D3.1 (K), U5.1 (P5.3)
/MPU_SCL: U3.23 (SCL), U5.9 (P1.5)
/MPU_SDA: U3.24 (SDA), U5.8 (P1.4)
/PWM1N: U5.6 (P1.1), U6.7 (BAK)
/PWM1P: U5.5 (P1.0), U6.6 (FOR)
/PWM4N: U5.11 (P1.7), U7.7 (BAK)
/PWM4P: U5.10 (P1.6), U7.6 (FOR)
/PWM5: J1.3, U5.33 (P2.0)
/PWM6: J2.3, U5.34 (P2.1)
/RF24_CE: U4.2 (CE), U5.40 (P2.7)
/RF24_CSN: U4.3 (CSN), U5.39 (P2.6)
/RF24_IRQ: U4.7 (IRQ), U5.35 (P2.2)
/RF24_MISO: U4.6 (MISO), U5.37 (P2.4)
/RF24_MOSI: U4.5 (MOSI), U5.36 (P2.3)
/RF24_SCK: U4.4 (SCK), U5.38 (P2.5)
GND: C1.2, C2.1, C5.2, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, J1.1, J2.1, Q1.2 (E), R1.1, R2.2, R3.2, R8.1, SW1.1 (A), SW2.2 (B), U1.1 (GND), U2.1 (TEMP), U2.3 (GND), U2.9 (EP), U3.1 (CLKIN), U3.9 (AD0), U3.11 (FSYNC), U3.18 (GND), U4.8 (GND), U5.17 (GND), U6.5 (GND), U6.8 (GND), U7.5 (GND), U7.8 (GND), USB1.1 (SHELL), USB1.2 (SHELL), USB1.3 (SHELL), USB1.4 (SHELL), USB1.A1B12 (GND), USB1.B1A12 (GND)
unnamed: BT1.1 (-), SW2.3 (C)
unnamed: BZ1.2 (+), D4.2 (A), Q1.3 (C)
unnamed: D1.1 (K), R4.2
unnamed: D2.1 (K), R5.2
unnamed: D3.2 (A), R6.1
unnamed: C17.1, M1.1 (+), U6.1 (X4)
unnamed: C17.2, M1.2 (-), U6.4 (X3)
unnamed: C18.1, M2.1 (+), U7.1 (X4)
unnamed: C18.2, M2.2 (-), U7.4 (X3)
unnamed: Q1.1 (B), R7.2, R8.2
unnamed: R12.2, SW1.2 (B)
unnamed: C1.1, D5.3, U1.3 (VI)
unnamed: R4.1, U2.7 (CHRG)
unnamed: R1.2, U2.2 (PROG)
unnamed: R5.1, U2.6 (STDBY)
unnamed: C8.1, U3.20 (CPOUT)
unnamed: C9.1, U3.10 (REGOUT)
unnamed: R9.2, U5.19 (P3.0)
unnamed: R10.2, U5.20 (P3.1)
unnamed: R11.1, R12.1, U5.21 (P3.2)
unnamed: C16.1, U5.13 (UCap)
unnamed: R2.1, USB1.A5 (CC1)
unnamed: R3.1, USB1.B5 (CC2)
VBUS: C2.2, D1.2 (A), D2.2 (A), D5.1, U2.4 (VCC), U2.8 (CE), USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)

Notes on the sheet:
硬件描述： 电池数：1S-3.7V 带报警功能 2.4G无线遥控 控制2路直流电机正反转，最大支持500mA 控制2路舵机 硬件组成： 主控：STC32G最小系统 陀螺仪：MPU6050 电机驱动:L9110S 舵机驱动：PWM 锂电池充放电：TC4056A 调试:LED/buzz/USB 电源：3.7V转3.3VLDO
DC MOTOR
USB
LED
MPU
LDO
Li-Po
SERVO
BUZZ
RF24
MCU

Board: 2 copper layers, 40.0 x 52.0 mm, 50 parts (0 on the bottom side), 45 nets.

## Code that names these connections

File Firmware/STC32_TEST/Inc/pwm.h:

#ifndef PWM_H
#define PWM_H

#include "stc32g.h"
#include "intrins.h"
#include "sys.h"

#if (USE_PWM == 1)

#define PWM1P_PIN P10
#define PWM1N_PIN P11
#define PWM4P_PIN P16
#define PWM4N_PIN P17

void pwm_init(void);
void pwma_setcycle(unsigned int cycle);
void pwm1_setduty(unsigned int duty);
void pwm4_setduty(unsigned int duty);
void pwm1p_enable(void);
void pwm1n_enable(void);
void pwm4p_enable(void);
void pwm4n_enable(void);
void pwm1p_disable(void);
void pwm1n_disable(void);
void pwm4p_disable(void);
void pwm4n_disable(void);

#endif

#endif

## Commit log

2023-06-02 新建硬件文件夹
2023-06-02 更新README，添加功能和硬件组成说明
2023-06-08 PCB完成初版设计，待验证
2023-06-16 硬件上传
2023-06-16 添加电灯程序
2023-06-18 补充测试PCB调试程序
2023-06-19 测试通过软件SPI的RF24L01程序
2023-06-20 RF24测试通过
2023-07-18 添加新PCB
2023-07-20 添加测试程序
2023-07-21 版本0.03验证完成
